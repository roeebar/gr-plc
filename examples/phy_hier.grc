<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8rc1'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>PHY</value></param>
<param><key>author</key><value>Roee Bar</value></param>
<param><key>category</key><value>PLC</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>PHY</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>amp</value></param>
<param><key>value</key><value>0.3</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>amp</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>1/amp</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>debug</value></param>
<param><key>label</key><value>Debug</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>info</value></param>
<param><key>label</key><value>Info</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>mac out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>samp out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>mac in</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>samp in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>plc_phy_rx</key>
<param><key>id</key><value>plc_phy_rx_0</value></param>
<param><key>debug</key><value>debug</value></param>
<param><key>info</key><value>info</value></param>
</block>
<block>
<key>plc_phy_tx</key>
<param><key>id</key><value>plc_phy_tx_0</value></param>
<param><key>debug</key><value>debug</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>plc_phy_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>plc_phy_rx_0</sink_block_id><source_key>0</source_key><sink_key>mac in</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>plc_phy_tx_0</sink_block_id><source_key>0</source_key><sink_key>mac in</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>plc_phy_rx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>mac out</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>plc_phy_tx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>mac out</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>plc_phy_tx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
