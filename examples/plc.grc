<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8rc1'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>plc_test</value></param>
<param><key>author</key><value>Roee Bar</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>12.5e6</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>function_probe_blocks_tx</value></param>
<param><key>block_id</key><value>plc_mac_0</value></param>
<param><key>function_args</key><value>"'n_blocks_tx_success'"</value></param>
<param><key>function_name</key><value>get_stats</value></param>
<param><key>poll_rate</key><value>1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>function_probe_blocks_tx_fail</value></param>
<param><key>block_id</key><value>plc_mac_0</value></param>
<param><key>function_args</key><value>"'n_blocks_tx_fail'"</value></param>
<param><key>function_name</key><value>get_stats</value></param>
<param><key>poll_rate</key><value>1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>function_probe_capacity</value></param>
<param><key>block_id</key><value>plc_mac_0</value></param>
<param><key>function_name</key><value>capacity</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>function_probe_missing_acks</value></param>
<param><key>block_id</key><value>plc_mac_0</value></param>
<param><key>function_args</key><value>"'n_missing_acks'"</value></param>
<param><key>function_name</key><value>get_stats</value></param>
<param><key>poll_rate</key><value>1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>function_probe_rate_in</value></param>
<param><key>block_id</key><value>probe_in</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>function_probe_rate_out</value></param>
<param><key>block_id</key><value>probe_out</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>25e6</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>settings</value></param>
<param><key>field0</key><value>ToneMode</value></param>
<param><key>field1</key><value>syncMask</value></param>
<param><key>field10</key><value>estMode</value></param>
<param><key>field2</key><value>broadcastMask</value></param>
<param><key>field3</key><value>targetBer</value></param>
<param><key>field4</key><value>gain</value></param>
<param><key>field5</key><value>log</value></param>
<param><key>field6</key><value>qpskMask</value></param>
<param><key>field7</key><value>sensitivity</value></param>
<param><key>field8</key><value>snr</value></param>
<param><key>field9</key><value>interframeSpace</value></param>
<param><key>value0</key><value>1</value></param>
<param><key>value2</key><value>[0]*512 + [1,0]*512 + [0]*512</value></param>
<param><key>value10</key><value>0</value></param>
<param><key>value4</key><value>0.55*0.15*0 + 0.3</value></param>
<param><key>value9</key><value>140*50*3</value></param>
<param><key>value5</key><value>1</value></param>
<param><key>value6</key><value>[0]*512 + [1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0]*64 + [0]*512</value></param>
<param><key>value7</key><value>0.75</value></param>
<param><key>value8</key><value>snr</value></param>
<param><key>value1</key><value>[0]*64 + [1,0]*64 + [0]*64</value></param>
<param><key>value3</key><value>0.01</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>function_probe_rate_in</value></param>
<param><key>gui_hint</key><value>2,1</value></param>
<param><key>label</key><value>Rate in (Bps)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0</value></param>
<param><key>value</key><value>function_probe_rate_out</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>label</key><value>Rate out (Bps)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_0</value></param>
<param><key>value</key><value>function_probe_capacity</value></param>
<param><key>gui_hint</key><value>4,1</value></param>
<param><key>label</key><value>Capacity (bits per symbol)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_2</value></param>
<param><key>value</key><value>function_probe_blocks_tx</value></param>
<param><key>gui_hint</key><value>5,1</value></param>
<param><key>label</key><value>PHY Blocks Success</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_2_0</value></param>
<param><key>value</key><value>function_probe_blocks_tx_fail</value></param>
<param><key>gui_hint</key><value>6,1</value></param>
<param><key>label</key><value>PHY Blocks Failed</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_2_0_0</value></param>
<param><key>value</key><value>function_probe_missing_acks</value></param>
<param><key>gui_hint</key><value>7,1</value></param>
<param><key>label</key><value>Missing ACKs</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>PHY</key>
<param><key>id</key><value>PHY_0</value></param>
<param><key>gain</key><value>settings.gain</value></param>
<param><key>log</key><value>1</value></param>
<param><key>sensitivity</key><value>settings.sensitivity</value></param>
</block>
<block>
<key>PHY</key>
<param><key>id</key><value>PHY_0_0</value></param>
<param><key>gain</key><value>settings.gain</value></param>
<param><key>log</key><value>0</value></param>
<param><key>sensitivity</key><value>settings.sensitivity</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/roee/signal.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/roee/Dropbox/Thesis/gr-plc/Testing/1516_x_334.mkv</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>(10**((2.2-settings.snr)/10)*settings.gain**2/8)**0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>(10**((2.2-30)/10)*settings.gain**2/8)**0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>noise_voltage</key><value>0.0</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>-0.000870+-0.000728j, -0.001094+-0.000150j, -0.000540+0.000450j, 0.000119+0.000407j, 0.000218+-0.000047j, -0.000058+-0.000247j, -0.000142+-0.000065j, 0.000043+0.000084j, 0.000151+-0.000000j, 0.000072+-0.000099j, 0.000016+-0.000061j, 0.000058+-0.000019j, 0.000056+-0.000073j, -0.000020+-0.000113j, -0.000028+-0.000066j, 0.000053+-0.000025j, 0.000072+-0.000049j, -0.000013+-0.000056j, -0.000062+0.000003j, -0.000005+0.000045j, 0.000054+0.000016j, 0.000040+-0.000020j, 0.000012+-0.000015j, 0.000020+-0.000015j, 0.000015+-0.000044j, -0.000024+-0.000041j, -0.000036+0.000009j, 0.000002+0.000033j, 0.000029+-0.000005j, 0.000010+-0.000039j, -0.000010+-0.000018j, 0.000000+0.000009j, 0.000003+0.000000j, -0.000017+-0.000008j, -0.000017+0.000013j, 0.000016+0.000024j, 0.000029+-0.000004j, 0.000001+-0.000028j, -0.000020+-0.000012j, -0.000006+0.000013j, 0.000009+0.000007j, 0.000000+-0.000007j, -0.000006+-0.000002j, 0.000007+0.000006j, 0.000012+-0.000005j, -0.000005+-0.000013j, -0.000014+0.000000j, -0.000000+0.000013j, 0.000009+0.000004j, 0.000000+0.000000j</value></param>
</block>
<block>
<key>plc_app_in</key>
<param><key>id</key><value>plc_app_in_0</value></param>
<param><key>log</key><value>0</value></param>
</block>
<block>
<key>plc_app_out</key>
<param><key>id</key><value>plc_app_out_0</value></param>
<param><key>log</key><value>0</value></param>
</block>
<block>
<key>plc_impulse_source</key>
<param><key>id</key><value>plc_impulse_source_0_0</value></param>
<param><key>a</key><value>[(10**((2.2-settings.snr)/10)*settings.gain**2*512/2/samp_rate*4*4.6/2/2e-6)**0.5,]*5</value></param>
<param><key>l</key><value>(4.6/2/2e-6,)*5</value></param>
<param><key>f</key><value>-samp_rate/4.0/3.0*2, -samp_rate/4.0/3.0, 0, samp_rate/4.0/3.0, samp_rate/4.0/3.0*2</value></param>
<param><key>iat</key><value>((4096+756-496)/2/samp_rate,)*5</value></param>
<param><key>n_noises</key><value>0</value></param>
<param><key>o</key><value>0/5.0, 1/5.0, 2/5.0, 3/5.0, 4/5.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>plc_mac</key>
<param><key>id</key><value>plc_mac_0</value></param>
<param><key>device_addr</key><value>[0x45, 0x45, 0x45, 0x45, 0x45, 0x45]</value></param>
<param><key>broadcast_tone_mask</key><value>settings.broadcastMask</value></param>
<param><key>channel_est_mode</key><value>2</value></param>
<param><key>dest_addr</key><value>[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]</value></param>
<param><key>interframe_space</key><value>settings.interframeSpace</value></param>
<param><key>log_level</key><value>settings.log</value></param>
<param><key>qpsk_tone_mask</key><value>[]</value></param>
<param><key>master</key><value>True</value></param>
<param><key>sync_tone_mask</key><value>settings.syncMask</value></param>
<param><key>target_ber</key><value>settings.targetBer</value></param>
<param><key>tmi</key><value>3</value></param>
</block>
<block>
<key>plc_mac</key>
<param><key>id</key><value>plc_mac_0_0</value></param>
<param><key>device_addr</key><value>[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]</value></param>
<param><key>broadcast_tone_mask</key><value>settings.broadcastMask</value></param>
<param><key>channel_est_mode</key><value>settings.estMode</value></param>
<param><key>dest_addr</key><value>[0x45, 0x45, 0x45, 0x45, 0x45, 0x45]</value></param>
<param><key>interframe_space</key><value>settings.interframeSpace</value></param>
<param><key>log_level</key><value>settings.log</value></param>
<param><key>qpsk_tone_mask</key><value>[] if settings.estMode!=1 else settings.qpskMask</value></param>
<param><key>master</key><value>False</value></param>
<param><key>sync_tone_mask</key><value>settings.syncMask</value></param>
<param><key>target_ber</key><value>settings.targetBer</value></param>
<param><key>tmi</key><value>0</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>probe_in</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>probe_out</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>snr</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>len_tag_name</key><value></value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>clock_source0</key><value>mimo</value></param>
<param><key>time_source0</key><value>mimo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>PHY_0</source_block_id><sink_block_id>plc_mac_0_0</sink_block_id><source_key>mac out</source_key><sink_key>phy in</sink_key></connection>
<connection><source_block_id>PHY_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PHY_0_0</source_block_id><sink_block_id>plc_mac_0</sink_block_id><source_key>mac out</source_key><sink_key>phy in</sink_key></connection>
<connection><source_block_id>PHY_0_0</source_block_id><sink_block_id>blocks_add_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>PHY_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_1</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_1</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>plc_app_out_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>probe_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>PHY_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>plc_app_in_0</source_block_id><sink_block_id>probe_in</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>plc_app_out_0</source_block_id><sink_block_id>plc_mac_0</sink_block_id><source_key>mac out</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>plc_impulse_source_0_0</source_block_id><sink_block_id>blocks_add_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>plc_mac_0</source_block_id><sink_block_id>plc_app_out_0</sink_block_id><source_key>app out</source_key><sink_key>mac in</sink_key></connection>
<connection><source_block_id>plc_mac_0</source_block_id><sink_block_id>PHY_0_0</sink_block_id><source_key>phy out</source_key><sink_key>mac in</sink_key></connection>
<connection><source_block_id>plc_mac_0_0</source_block_id><sink_block_id>plc_app_in_0</sink_block_id><source_key>app out</source_key><sink_key>mac in</sink_key></connection>
<connection><source_block_id>plc_mac_0_0</source_block_id><sink_block_id>PHY_0</sink_block_id><source_key>phy out</source_key><sink_key>mac in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>PHY_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
